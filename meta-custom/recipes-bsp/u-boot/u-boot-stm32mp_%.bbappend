FILESEXTRAPATHS_prepend := "${THISDIR}:"

//SRC_URI += "file://0001-Comment-out-usb-power.patch \
//            file://0002-Modify-u-boot-control.patch \
//            file://0006-Modify-exlinux.conf-odyssey.patch \
//            "
