FILESEXTRAPATHS_prepend := "${THISDIR}:"

//SRC_URI += "file://0001-Add-i2c2-addr-node.patch \
//            file://0002-Add-i2c2-base.patch \
//            file://0003-Add-i2c2-base-case.patch \
//            file://0004-Add-PMIC-i2c2-support.patch \
//            file://0005-Modify-DDR3-to-512MB.patch \
//            file://0006-Modify-PMIC-SDMMC2.patch \
//            file://0007-Add-i2c2-clk.patch \
//            file://0008-Add-i2c2-pins.patch \
//            "

