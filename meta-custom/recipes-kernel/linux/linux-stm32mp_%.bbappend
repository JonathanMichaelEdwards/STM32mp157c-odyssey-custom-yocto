FILESEXTRAPATHS_prepend := "${THISDIR}:"

//SRC_URI += "file://0001-Modify-PMIC-SDMMC2.patch \
//            "
